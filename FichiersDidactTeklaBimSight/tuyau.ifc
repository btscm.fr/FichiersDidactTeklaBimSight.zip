Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2015-03-07T22:38:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 07 22:38:06 2015 * Host: vincent-HP * Database: C:\Users\vincent\AppData\Local\Temp\{9934B8C9-ECD2-4F85-98BB-452ED88F9EEE}\ifc * Database version: 5507 * Database creation date: Sat Mar 07 22:38:05 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 07 22:38:05 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 07 22:38:05 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Ligne du Niveau; Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau; Nom de la famille: Niveau
Contraintes - Elévation: 0 m; Base de l'élévation: Point de base du projet
Cotes - Hauteur de calcul: 0 m

# IfcFlowSegment: Canalisation:Valeur par défaut, Canalisation:Valeur par défaut:237639
In: Niveau 0
Type - Autre - Catégorie: Canalisation; Nom de la famille: Canalisation
Type - Données d'identification - Nom du type: Valeur par défaut
Pset_DistributionFlowElementCommon - Reference: Valeur par défaut
Autre - Famille: Canalisation: Valeur par défaut; Famille et type: Canalisation: Valeur par défaut; ID du type: Canalisation: Valeur par défaut; Type: Canalisation: Valeur par défaut
Contraintes - Décalage de départ: 2.7432 m; Décalage extrémité: 2.7432 m; Décaler: 2.7432 m; Inclinaison: 0; Justification horizontale: Centre; Justification verticale: Milieu; Niveau de référence: Niveau: Niveau 0
Cotes - Diamètre extérieur: 0.168275 m; Diamètre intérieur: 0.154051 m; Longueur: 8.4 m; Taille: 150 mmø
Données d'identification - Identifiant: 3
Génie climatique - Classification du système: Alimentation hydraulique; Coupe: 1; Diamètre: 0.15 m; Inverser l'élévation: 2.66617 m; Matériau: Acier, carbone; Nom du système: Alimentation hydraulique 1; Nomenclature/type: Types de nomenclatures de canalisations: Nomenclature 40; Rugosité: 0.0139355 m; Segment de canalisation: Acier au carbone - Nomenclature 40; Surface: 3.95841 m2; Type de connexion: Générique; Type de système: Système de canalisation: Alimentation hydraulique
Génie climatique - Ecoulement - Etat du flux: Laminaire; Facteur de frottement: 0; Flux: 0 m3/s; Flux supplémentaire: 0 m3/s; Frottement: 0; Nombre de Reynolds: 0; Perte de charge: 0 Pa; Rugosité relative: 0.09046; Vitesse: 0
Isolation - Epaisseur d'isolation: 0 m; Taille globale: 150 mmø
Phase de construction - Phase de création: Nouvelle construction
