Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2015-03-07T22:37:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 07 22:37:25 2015 * Host: vincent-HP * Database: C:\Users\vincent\AppData\Local\Temp\{D8C0428B-5E74-416E-87BA-1AF77F4A70A4}\ifc * Database version: 5507 * Database creation date: Sat Mar 07 22:37:23 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 07 22:37:23 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 07 22:37:23 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 2
LongName: Niveau 2; Elevation: 4 m
Graphismes - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Ligne du Niveau; Etage de bâtiment: yes; Nom: Niveau 2; Structure: no
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau; Nom de la famille: Niveau
Contraintes - Elévation: 4 m; Base de l'élévation: Point de base du projet
Cotes - Hauteur de calcul: 0 m

# IfcBeam: IPE-Poutrelles:IPE140:237064, IPE-Poutrelles:IPE140:237147
In: Niveau 2
Material: Métal - Acier - 345 MPa
Pset_BeamCommon - Reference: IPE140; LoadBearing: yes; IsExternal: no; Span: 12.149 m; Slope: 0.235803 deg
Autre - Catégorie: Ossature; Famille: IPE-Poutrelles: IPE140; Famille et type: IPE-Poutrelles: IPE140; ID du type: IPE-Poutrelles: IPE140; Type: IPE-Poutrelles: IPE140; Nom de la famille: IPE-Poutrelles
Contraintes - Décalage du niveau d'arrivée: -0.45 m; Décalage du niveau de départ: -0.5 m; Niveau de référence: Niveau: Niveau 2; Rotation de la section: 0 deg
Cotes - Longueur: 12.149 m; Volume: 0.019445 m3; bf: 0.073 m; d: 0.14 m; k: 0.0139 m; tf: 0.0069 m; tr: 0.007 m; tw: 0.0047 m
Matériaux et finitions - Matériau structurel: Métal - Acier - 345 MPa
Phase de construction - Phase de création: Nouvelle construction
Position géométrique - Etat de la jonction: Deux jonctions activées; Extension de départ: 0 m; Extension de fin: 0 m; Justification Y: Origine; Justification YZ: Uniforme; Justification Z: Haut; Valeur de décalage Y: 0 m; Valeur de décalage Z: 0 m
Structure - Activer le modèle analytique: yes; Emplacement du symbole filaire: Centre de la géométrie; Longueur de coupe: 12.149 m; Utilisation structurelle: Longeron; A: 0.001643 m2; Forme de coupe: 0; W: 0.126506
Données d'identification - Nom du type: IPE140
